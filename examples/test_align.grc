<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>14370e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resample</value></param>
<param><key>value</key><value>12000/8000.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>spec_max</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>max (dB)</value></param>
<param><key>min_len</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-120</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>spec_min</value></param>
<param><key>value</key><value>-120</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>min (dB)</value></param>
<param><key>min_len</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-140</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(4, 4*samp_rate/resample, samp_rate/resample*0.5, samp_rate/resample*0.02, 80, 5)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_resampler</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, 0.5*samp_rate/resample, samp_rate/resample*0.02)</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate/resample*4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>/Users/chm/Software/gr-kiwisdr/build/test.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>int(round(samp_rate*4/resample))</value></param>
</block>
<block>
<key>kiwisdr_align_streams</key>
<param><key>id</key><value>kiwisdr_align_streams_0</value></param>
<param><key>num_streams</key><value>3</value></param>
</block>
<block>
<key>kiwisdr_kiwi_wav_source</key>
<param><key>id</key><value>kiwisdr_kiwi_wav_source_0</value></param>
<param><key>filename</key><value>/Users/chm/Software/gr-kiwisdr/examples/20190129T103700Z_14370000_IS0KYB_iq.wav</value></param>
</block>
<block>
<key>kiwisdr_kiwi_wav_source</key>
<param><key>id</key><value>kiwisdr_kiwi_wav_source_1</value></param>
<param><key>filename</key><value>/Users/chm/Software/gr-kiwisdr/examples/20190129T103700Z_14378000_IS0KYB_iq.wav</value></param>
</block>
<block>
<key>kiwisdr_kiwi_wav_source</key>
<param><key>id</key><value>kiwisdr_kiwi_wav_source_1_0</value></param>
<param><key>filename</key><value>/Users/chm/Software/gr-kiwisdr/examples/20190129T103700Z_14362000_IS0KYB_iq.wav</value></param>
</block>
<block>
<key>pfb_synthesizer_ccf</key>
<param><key>id</key><value>pfb_synthesizer_ccf_0</value></param>
<param><key>twox</key><value>False</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>ch_map</key><value>[3,0,1,2]</value></param>
<param><key>numchans</key><value>4</value></param>
<param><key>connections</key><value>3</value></param>
<param><key>taps</key><value>taps</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate*4/resample</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>int_max</key><value>spec_max</value></param>
<param><key>int_min</key><value>spec_min</value></param>
<param><key>name</key><value>"Streams #0,#1,#2 combined"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>.02</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/resample</value></param>
<param><key>fc</key><value>fc-samp_rate/resample</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>int_max</key><value>spec_max</value></param>
<param><key>int_min</key><value>spec_min</value></param>
<param><key>name</key><value>"Stream #0"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>.02</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0_0</value></param>
<param><key>bw</key><value>samp_rate/resample</value></param>
<param><key>fc</key><value>fc+samp_rate/resample</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>int_max</key><value>spec_max</value></param>
<param><key>int_min</key><value>spec_min</value></param>
<param><key>name</key><value>"Stream #2"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>.02</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0_1</value></param>
<param><key>bw</key><value>samp_rate/resample</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>int_max</key><value>spec_max</value></param>
<param><key>int_min</key><value>spec_min</value></param>
<param><key>name</key><value>"Stream #1"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>.02</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>3</value></param>
<param><key>fbw</key><value>2./6</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>taps</key><value>taps_resampler</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>3</value></param>
<param><key>fbw</key><value>2./6</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>taps</key><value>taps_resampler</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1</value></param>
<param><key>decim</key><value>3</value></param>
<param><key>fbw</key><value>2./6</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>taps</key><value>taps_resampler</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_align_streams_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_align_streams_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_align_streams_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_kiwi_wav_source_0</source_block_id><sink_block_id>kiwisdr_align_streams_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>kiwisdr_kiwi_wav_source_1</source_block_id><sink_block_id>kiwisdr_align_streams_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>kiwisdr_kiwi_wav_source_1_0</source_block_id><sink_block_id>kiwisdr_align_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_synthesizer_ccf_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>pfb_synthesizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>pfb_synthesizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1</source_block_id><sink_block_id>pfb_synthesizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
