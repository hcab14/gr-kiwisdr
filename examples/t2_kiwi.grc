options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: constell
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {}
- name: fn
  id: variable
  parameters:
    value: '''z5'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: fn+'_soft_dec.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: fn+'_phase.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: fn+'_hard_dec.bin'
    type: byte
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: fn+'_symb.bin'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '3.5'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constell
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constell
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '8'
    w: 6.28/100*0.01
  states: {}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: constell
    mu: '0.01'
    num_taps: '21'
    sps: '1'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts*0.9
    loop_bw: 6.28/100.0
    max_dev: 1.5*0.1
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: kiwisdr_kiwisdr_0
  id: kiwisdr_kiwisdr
  parameters:
    high_cut_Hz: '1400'
    host: aspliden.mooo.com
    low_cut_Hz: '-1400'
    mod: iq
    port: '8073'
    rx_freq_kHz: '4932'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 12001.0/12000
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: err
    label2: rate
    label3: phase
    nconnections: '3'
    size: '1024'
    srate: samp_rate/sps
    type: float
    update_time: '.1'
    ylabel: err
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', mmse_resampler_xx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0_1, '0']
- [digital_constellation_soft_decoder_cf_0, '0', blocks_file_sink_0, '0']
- [digital_costas_loop_cc_0, '0', digital_lms_dd_equalizer_cc_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', blocks_file_sink_0_2, '0']
- [digital_lms_dd_equalizer_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '1', qtgui_time_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '2', qtgui_time_sink_x_0, '1']
- [digital_pfb_clock_sync_xxx_0, '3', blocks_file_sink_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '3', qtgui_time_sink_x_0, '2']
- [kiwisdr_kiwisdr_0, '0', blocks_throttle_0, '0']
- [mmse_resampler_xx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']

metadata:
  file_format: 1
