<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delta_f</value></param>
<param><key>comment</key><value>frequency distance (in Hz)
between the input streams</value></param>
<param><key>value</key><value>15000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>comment</key><value>center frequency
(used only for display)</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nskip</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>comment</key><value>Sample rate 
of the input streams</value></param>
<param><key>value</key><value>20250</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>spec_max</value></param>
<param><key>value</key><value>-30</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>max (dB)</value></param>
<param><key>min_len</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-120</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>spec_min</value></param>
<param><key>value</key><value>-80</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>min (dB)</value></param>
<param><key>min_len</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-140</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>110</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>110</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>498</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0_1</value></param>
<param><key>num_items</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>498</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_2</value></param>
<param><key>num_items</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>4*delta_f</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>test.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>4*delta_f</value></param>
</block>
<block>
<key>kiwisdr_coh_stream_synth</key>
<param><key>id</key><value>kiwisdr_coh_stream_synth_0</value></param>
<param><key>df_in</key><value>delta_f</value></param>
<param><key>fs_in</key><value>samp_rate</value></param>
<param><key>skip</key><value>nskip</value></param>
</block>
<block>
<key>kiwisdr_kiwi_wav_source</key>
<param><key>id</key><value>kiwisdr_kiwi_wav_source_0</value></param>
<param><key>filename</key><value>/Users/chm/Software/gr-kiwisdr/examples/WBHF/c.wav</value></param>
<param><key>ref_freq</key><value>delta_f/2.0</value></param>
</block>
<block>
<key>kiwisdr_kiwi_wav_source</key>
<param><key>id</key><value>kiwisdr_kiwi_wav_source_1</value></param>
<param><key>filename</key><value>/Users/chm/Software/gr-kiwisdr/examples/WBHF/h.wav</value></param>
<param><key>ref_freq</key><value>delta_f/2.0</value></param>
</block>
<block>
<key>kiwisdr_kiwi_wav_source</key>
<param><key>id</key><value>kiwisdr_kiwi_wav_source_1_0</value></param>
<param><key>filename</key><value>/Users/chm/Software/gr-kiwisdr/examples/WBHF/l.wav</value></param>
<param><key>ref_freq</key><value>delta_f/2.0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>gui_hint</key><value>2,1,2,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>relative phase #2-#1</value></param>
<param><key>label2</key><value>relative phase #0-#1</value></param>
<param><key>name</key><value>"phase offset QA"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>1.2</value></param>
<param><key>xmin</key><value>-1.2</value></param>
<param><key>ymax</key><value>1.2</value></param>
<param><key>ymin</key><value>-1.2</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>delta_f*4</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>int_max</key><value>spec_max</value></param>
<param><key>int_min</key><value>spec_min</value></param>
<param><key>name</key><value>"Streams #0,#1,#2 combined"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>.02</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>delta_f</value></param>
<param><key>fc</key><value>fc-delta_f</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>int_max</key><value>spec_max</value></param>
<param><key>int_min</key><value>spec_min</value></param>
<param><key>name</key><value>"Stream #0"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>.02</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0_0</value></param>
<param><key>bw</key><value>delta_f</value></param>
<param><key>fc</key><value>fc+delta_f</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>int_max</key><value>spec_max</value></param>
<param><key>int_min</key><value>spec_min</value></param>
<param><key>name</key><value>"Stream #2"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>.02</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0_1</value></param>
<param><key>bw</key><value>delta_f</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>int_max</key><value>spec_max</value></param>
<param><key>int_min</key><value>spec_min</value></param>
<param><key>name</key><value>"Stream #1"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>.02</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>kiwisdr_coh_stream_synth_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>kiwisdr_coh_stream_synth_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0_0</source_block_id><sink_block_id>kiwisdr_coh_stream_synth_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0_1</source_block_id><sink_block_id>kiwisdr_coh_stream_synth_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_1</source_block_id><sink_block_id>kiwisdr_coh_stream_synth_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_2</source_block_id><sink_block_id>kiwisdr_coh_stream_synth_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_coh_stream_synth_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_coh_stream_synth_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_coh_stream_synth_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_coh_stream_synth_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_coh_stream_synth_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_coh_stream_synth_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>5</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>kiwisdr_kiwi_wav_source_0</source_block_id><sink_block_id>blocks_skiphead_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_kiwi_wav_source_0</source_block_id><sink_block_id>blocks_skiphead_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_kiwi_wav_source_1</source_block_id><sink_block_id>blocks_skiphead_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_kiwi_wav_source_1</source_block_id><sink_block_id>blocks_skiphead_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_kiwi_wav_source_1_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_kiwi_wav_source_1_0</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
