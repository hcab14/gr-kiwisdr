options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    thread_safe_setters: '1'
  states: {}

blocks:
- name: delta_f
  id: variable
  parameters:
    comment: |-
      frequency distance (in Hz)
      between the input streams
    value: '15000'
  states: {}
- name: fc
  id: variable
  parameters:
    comment: |-
      center frequency
      (used only for display)
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Sample rate 
      of the input streams
    value: '20250'
  states: {}
- name: spec_max
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: max (dB)
    min_len: '1'
    orient: Qt.Horizontal
    start: '-120'
    step: '1'
    stop: '20'
    value: '-30'
  states: {}
- name: spec_min
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: min (dB)
    min_len: '1'
    orient: Qt.Horizontal
    start: '-140'
    step: '1'
    stop: '20'
    value: '-80'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 4*delta_f*2
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: test.wav
    nchan: '2'
    samp_rate: 4*delta_f
  states: {}
- name: kiwisdr_coh_stream_synth_0
  id: kiwisdr_coh_stream_synth
  parameters:
    df_in: delta_f
    fs_in: samp_rate
    num_streams: '3'
  states: {}
- name: kiwisdr_kiwi_wav_source_0
  id: kiwisdr_kiwi_wav_source
  parameters:
    filename: ''
  states: {}
- name: kiwisdr_kiwi_wav_source_0_0
  id: kiwisdr_kiwi_wav_source
  parameters:
    filename: ''
  states: {}
- name: kiwisdr_kiwi_wav_source_1_0
  id: kiwisdr_kiwi_wav_source
  parameters:
    filename: ''
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: '#0-#1'
    label2: '#1-#2'
    name: '"phase QA"'
    nconnections: '2'
    size: '1024'
    type: complex
    xmax: '1.2'
    xmin: '-1.2'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: 4*delta_f
    fc: '0'
    fftsize: 1024*2
    grid: 'True'
    gui_hint: tab@0:[1,0,1,3]
    legend: 'False'
    name: '"Streams #0,#1 combined"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: spec_max
    ymin: spec_min
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: 2*delta_f
    fc: fc-delta_f
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab@0:[0,0,1,1]
    label: Relative Strength
    label1: '""'
    legend: 'False'
    name: '"stream #0"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: spec_max
    ymin: spec_min
  states: {}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: 2*delta_f
    fc: fc
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab@0:[0,1,1,1]
    label: Relative Strength
    legend: 'False'
    name: '"stream #1"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: spec_max
    ymin: spec_min
  states: {}
- name: qtgui_freq_sink_x_1_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: 2*delta_f
    fc: fc
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab@0:[0,2,1,1]
    label: Relative Strength
    legend: 'False'
    name: '"stream #2"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: spec_max
    ymin: spec_min
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: delta_f*4
    fc: fc
    fftsize: 1024*2
    gui_hint: tab@1:[1,0,1,3]
    int_max: spec_max
    int_min: spec_min
    name: '"Streams #0,#1 combined"'
    showports: 'True'
    type: complex
    update_time: '.02'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: delta_f*2
    fc: fc-delta_f
    fftsize: '1024'
    gui_hint: tab@1:[0,0,1,1]
    int_max: spec_max
    int_min: spec_min
    name: '"Stream #0"'
    showports: 'True'
    type: complex
    update_time: '.02'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: delta_f*2
    fc: fc
    fftsize: '1024'
    gui_hint: tab@1:[0,1,1,1]
    int_max: spec_max
    int_min: spec_min
    name: '"Stream #1"'
    showports: 'True'
    type: complex
    update_time: '.02'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: delta_f*2
    fc: fc
    fftsize: '1024'
    gui_hint: tab@1:[0,2,1,1]
    int_max: spec_max
    int_min: spec_min
    name: '"Stream #2"'
    showports: 'True'
    type: complex
    update_time: '.02'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,1,4,1
    label0: Spectrum
    label1: Waterfall
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: comb
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: resamp#0
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: resamp#1
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: resamp#2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: comb
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: resamp#0
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: resamp#1
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: resamp#2
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_throttle_0, '0', blocks_complex_to_float_0, '0']
- [kiwisdr_coh_stream_synth_0, '0', blocks_throttle_0, '0']
- [kiwisdr_coh_stream_synth_0, '0', virtual_sink_0, '0']
- [kiwisdr_coh_stream_synth_0, '1', virtual_sink_0_0, '0']
- [kiwisdr_coh_stream_synth_0, '2', virtual_sink_0_0_0, '0']
- [kiwisdr_coh_stream_synth_0, '3', virtual_sink_0_0_0_0, '0']
- [kiwisdr_coh_stream_synth_0, '4', qtgui_const_sink_x_0_0, '0']
- [kiwisdr_coh_stream_synth_0, '5', qtgui_const_sink_x_0_0, '1']
- [kiwisdr_kiwi_wav_source_0, '0', kiwisdr_coh_stream_synth_0, '1']
- [kiwisdr_kiwi_wav_source_0_0, '0', kiwisdr_coh_stream_synth_0, '2']
- [kiwisdr_kiwi_wav_source_1_0, '0', kiwisdr_coh_stream_synth_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [virtual_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [virtual_source_0_1, '0', qtgui_freq_sink_x_1_0_0, '0']
- [virtual_source_0_1, '0', qtgui_waterfall_sink_x_0_0_1, '0']
- [virtual_source_0_1_0, '0', qtgui_freq_sink_x_1_0_0_0, '0']
- [virtual_source_0_1_0, '0', qtgui_waterfall_sink_x_0_0_1_0, '0']

metadata:
  file_format: 1
