<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>high_cut_Hz</value></param>
<param><key>value</key><value>samp_rate//2</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
<param><key>label</key><value>IF high cut (Hz)</value></param>
<param><key>min_len</key><value>500</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate//2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>+samp_rate//2</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>host_name</value></param>
<param><key>comment</key><value>KiwiSDR
hostname
(as string)</value></param>
<param><key>value</key><value>'jimlill.com'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>label</value></param>
<param><key>value</key><value>'{}:{}'.format(host_name, port_number)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>low_cut_Hz</value></param>
<param><key>value</key><value>-samp_rate//2</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>IF low cut (Hz)</value></param>
<param><key>min_len</key><value>500</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate//2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>+samp_rate//2</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>port_number</value></param>
<param><key>comment</key><value>KiwiSDR
port number
(as string)</value></param>
<param><key>value</key><value>'8073'</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_center_freq_kHz</value></param>
<param><key>value</key><value>4907.8</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>RX center frequency (kHz)</value></param>
<param><key>min_len</key><value>500</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>30e3</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>comment</key><value>KiwiSDR
sample rate
(12000 or 20250)</value></param>
<param><key>value</key><value>20250</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wf_max</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-150</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>150</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wf_min</value></param>
<param><key>value</key><value>-100</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-150</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>150</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import kiwisdr</value></param>
</block>
<block>
<key>kiwisdr_kiwisdr</key>
<param><key>id</key><value>kiwisdr_kiwisdr_1</value></param>
<param><key>host</key><value>'{}'.format(host_name)</value></param>
<param><key>high_cut_Hz</key><value>high_cut_Hz</value></param>
<param><key>low_cut_Hz</key><value>low_cut_Hz</value></param>
<param><key>mod</key><value>iq</value></param>
<param><key>port</key><value>'{}'.format(port_number)</value></param>
<param><key>rx_freq_kHz</key><value>rx_center_freq_kHz</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>1e3*rx_center_freq_kHz</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@1:[0,0,2,2]</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"spectrum @"+label</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>wf_max</value></param>
<param><key>ymin</key><value>wf_min</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>1e3*rx_center_freq_kHz</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>gui_hint</key><value>tab@0:[0,0,2,2]</value></param>
<param><key>int_max</key><value>wf_max</value></param>
<param><key>int_min</key><value>wf_min</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"waterfall @" + label</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>gui_hint</key><value>0,0,2,2</value></param>
<param><key>label0</key><value>waterfall</value></param>
<param><key>label1</key><value>spectrum</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>kiwisdr_kiwisdr_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiwisdr_kiwisdr_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
